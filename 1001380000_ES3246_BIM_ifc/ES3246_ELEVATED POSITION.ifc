Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-10-07T19:32:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 07 19:32:02 2021 * Host: CHTSW00356 * Database: C:\Users\174558\AppData\Local\Temp\{B7F31FA8-DEF0-4A79-A118-857E732A0245}\ifc * Database version: 5507 * Database creation date: Thu Oct 07 19:31:48 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 07 19:31:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 07 19:31:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcTransportElement: JLG_Site_ Electic Scissor Lift ES3246, JLG_Site_ Electic Scissor Lift ES3246:JLG_Site_ Electic Scissor Lift ES3246:7956295
In: Level 1
Type - Material: JLG_Paint_Black, JLG_Metal Paint_White, JLG_Plastic_Yellow, JLG_Paint_Orange, JLG_Paint_Blue, JLG_Paint_Beige, JLG_Plastic_Dark Grey, JLG_Paint_Silver Grey, JLG_Rubber_Black, JLG_Plastic_Red, JLG_Rubber_Light Grey
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG_Electric Scissor Lift; Manufacturer: JLG; ProductionYear: n/a
